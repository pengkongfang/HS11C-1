# Keil uVision project template.uvprojx, settings and files
target template_Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IROM(0x00000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(48000000) ESEL ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=4
  c include: ..\..\..\mcu\common;..\source;..\..\..\driver\inc;..\user
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --keep=*Handler
  group common
    ./: startup_hc32l13x.s
    ../../../mcu/common/: system_hc32l13x.c interrupts_hc32l13x.c
  group source
    ../user/: user_sever.c
    ../source/: main.c
  group driver
    ../../../driver/src/: ddl.c sysctrl.c adt.c bt.c crc.c flash.c gpio.c pca.c reset.c rtc.c spi.c trim.c uart.c vc.c wdt.c
  group user
    ../user/: beep.c CRC16.c dui.c key.c timer.c uart_sever.c user_uart.c
  group LCD
    ../user/: misc.c menu_Frame.c lcd12864.c lcd_Drive.c oledpage.h
  group README
    ../: readme.txt
software components: CMSIS:CORE 4.1.0
